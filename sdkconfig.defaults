## sdkconfig.defaults
```kconfig
# TinyUSB Configuration
CONFIG_TINYUSB_CDC_ENABLED=y
CONFIG_TINYUSB_NET_MODE_NCM=y
```
